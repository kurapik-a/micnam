# Keil uVision project master.uvprojx, settings and files
target master (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: -AT32F435CGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.1
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: master +hex
  AfterMake: fromelf --text -s --output="$L@L.map" "!L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F435ZMT7,USE_STDPERIPH_DRIVER,AT_START_F435_V1
  c include: .\inc;.\libs\cmsis\cm4\core_support;.\libs\cmsis\cm4\device_support;.\libs\drivers\inc;.\libs\at32f435_437_board;.\modules;.\components\i2c_application_library;.\components\OLED;.\components\jy61p;.\src;.\modules\QMI8658;.\components\freertos\source;.\components\freertos\source\include;.\components\freertos\source\portable\rvds\ARM_CM4F;.\components\freertos\source\portable\memmang
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ./src/: main.c main.h at32f435_437_clock.c at32f435_437_int.c
    ./modules/: bsp.c can_wheel.c mecanum.c
    ./components/OLED/: OLED.c
    ./components/jy61p/: jy61p.c
  group bsp
    ./libs/at32f435_437_board/: at32f435_437_board.c
  group firmware
    ./libs/drivers/src/: at32f435_437_acc.c at32f435_437_adc.c at32f435_437_can.c at32f435_437_crc.c at32f435_437_crm.c at32f435_437_dac.c at32f435_437_debug.c at32f435_437_dma.c at32f435_437_dvp.c at32f435_437_edma.c at32f435_437_emac.c at32f435_437_ertc.c at32f435_437_exint.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_misc.c at32f435_437_pwc.c at32f435_437_qspi.c at32f435_437_scfg.c at32f435_437_sdio.c at32f435_437_spi.c at32f435_437_tmr.c at32f435_437_usart.c at32f435_437_usb.c at32f435_437_wdt.c at32f435_437_wwdt.c at32f435_437_xmc.c
    ./components/i2c_application_library/: i2c_application.c
  group cmsis
    ./libs/cmsis/cm4/device_support/: system_at32f435_437.c
    ./libs/cmsis/cm4/device_support/startup/mdk/: startup_at32f435_437.s
  group QMI8658
    ./modules/QMI8658/: QMI8658.C QMI8658.H
  group freeRTOS
    ./components/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./components/freertos/source/include/: FreeRTOSConfig.h FreeRTOS.h
    ./components/freertos/source/portable/memmang/: heap_4.c
    ./components/freertos/source/portable/rvds/ARM_CM4F/: port.c
