# Keil uVision project wheel.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LKS32MC454NCQ8 Linko
  pack: Linko.LKS45x.1.2.4
  cpu: IRAM(0x20000000,0xA000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: wheel +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=7 wLevel=2
  c include: .\src;.\libs\Source;.\libs\Include;D:\Program Files\Keil5\ARM\PACK\Linko\LKS45x\1.2.4\Device\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  link misc: --map
  group src
    ./src/: main.c main.h SystemInit.c mymode.c mymode.h FOC.c FOC.h MY_irq.c MY_irq.h
  group libs
    ./libs/Source/: lks32mc45x_adc.c lks32mc45x_afe.c lks32mc45x_aon.c lks32mc45x_can.c lks32mc45x_cmp.c lks32mc45x_cordic.c lks32mc45x_crc.c lks32mc45x_dma.c lks32mc45x_flash.c lks32mc45x_fmac.c lks32mc45x_gpio.c lks32mc45x_hall.c lks32mc45x_i2c.c lks32mc45x_iwdg.c lks32mc45x_mcpwm.c lks32mc45x_nvr.c lks32mc45x_qep.c lks32mc45x_spi.c lks32mc45x_sys.c lks32mc45x_trim.s lks32mc45x_uart.c lks32mc45x_utimer.c lks32mc45x_wwdg.c startup_lks32mc45x.s
software components: CMSIS:CORE 5.5.0
